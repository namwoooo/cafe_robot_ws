Commit message: fix: adjust camera height and pitch in SDF

File: src/cafe_robot/urdf/turtlebot3_burger_camera.urdf (robot description, URDF)
Before this commit: robot turtlebot3_burger, 9 links, 8 joints
Joints:
- joint camera_joint: origin xyz=0.07 0 0.1 rpy=0 0 0 -> xyz=0.07 0 1.5 rpy=0 1.0 0
